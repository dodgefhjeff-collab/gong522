#include "CRC16.h"
#include "gd32c10x.h"

const unsigned char CRC16_hi_lut[256] = {
    0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,
    0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,
    0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,
    0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,
    0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,
    0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,
    0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,
    0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,
    0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,
    0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,
    0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,
    0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,
    0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,
    0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,
    0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,
    0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02
};

//CRC-16低字节查找表
const unsigned char CRC16_lo_lut[256] = {
    0x00,0x05,0x0f,0x0a,0x1b,0x1e,0x14,0x11,0x33,0x36,0x3c,0x39,0x28,0x2d,0x27,0x22,
    0x63,0x66,0x6c,0x69,0x78,0x7d,0x77,0x72,0x50,0x55,0x5f,0x5a,0x4b,0x4e,0x44,0x41,
    0xc3,0xc6,0xcc,0xc9,0xd8,0xdd,0xd7,0xd2,0xf0,0xf5,0xff,0xfa,0xeb,0xee,0xe4,0xe1,
    0xa0,0xa5,0xaf,0xaa,0xbb,0xbe,0xb4,0xb1,0x93,0x96,0x9c,0x99,0x88,0x8d,0x87,0x82,
    0x83,0x86,0x8c,0x89,0x98,0x9d,0x97,0x92,0xb0,0xb5,0xbf,0xba,0xab,0xae,0xa4,0xa1,
    0xe0,0xe5,0xef,0xea,0xfb,0xfe,0xf4,0xf1,0xd3,0xd6,0xdc,0xd9,0xc8,0xcd,0xc7,0xc2,
    0x40,0x45,0x4f,0x4a,0x5b,0x5e,0x54,0x51,0x73,0x76,0x7c,0x79,0x68,0x6d,0x67,0x62,
    0x23,0x26,0x2c,0x29,0x38,0x3d,0x37,0x32,0x10,0x15,0x1f,0x1a,0x0b,0x0e,0x04,0x01,
    0x03,0x06,0x0c,0x09,0x18,0x1d,0x17,0x12,0x30,0x35,0x3f,0x3a,0x2b,0x2e,0x24,0x21,
    0x60,0x65,0x6f,0x6a,0x7b,0x7e,0x74,0x71,0x53,0x56,0x5c,0x59,0x48,0x4d,0x47,0x42,
    0xc0,0xc5,0xcf,0xca,0xdb,0xde,0xd4,0xd1,0xf3,0xf6,0xfc,0xf9,0xe8,0xed,0xe7,0xe2,
    0xa3,0xa6,0xac,0xa9,0xb8,0xbd,0xb7,0xb2,0x90,0x95,0x9f,0x9a,0x8b,0x8e,0x84,0x81,
    0x80,0x85,0x8f,0x8a,0x9b,0x9e,0x94,0x91,0xb3,0xb6,0xbc,0xb9,0xa8,0xad,0xa7,0xa2,
    0xe3,0xe6,0xec,0xe9,0xf8,0xfd,0xf7,0xf2,0xd0,0xd5,0xdf,0xda,0xcb,0xce,0xc4,0xc1,
    0x43,0x46,0x4c,0x49,0x58,0x5d,0x57,0x52,0x70,0x75,0x7f,0x7a,0x6b,0x6e,0x64,0x61,
    0x20,0x25,0x2f,0x2a,0x3b,0x3e,0x34,0x31,0x13,0x16,0x1c,0x19,0x08,0x0d,0x07,0x02
};

//                功能：帧CRC-16的计算 (高低字节分别查表法)                           //
//  参数说明：frame数据缓存区
//			  len数据总长度，待校验数据长度len-2，最后两个字节为crc16                  //

void CRC16_build(unsigned char *frame, unsigned int len)
{
    unsigned char *crcptr;
    unsigned char crc_hi,crc_lo,byte_temp;
    //unsigned short crc16Result;
    
    int i;

    crc_hi=0x00;
    crc_lo=0x00;
    crcptr=frame;	    //数据起始地址
    for(i=0; i<(len-2); i++)
    {
        byte_temp=crc_hi ^ *(crcptr+i);
        crc_hi=crc_lo ^ *(CRC16_hi_lut+byte_temp);
        crc_lo=*(CRC16_lo_lut+byte_temp);
    }
    frame[len-2]=crc_hi;
    frame[len-1]=crc_lo;
}

short CRC16_Get(unsigned char *frame, unsigned int len)
{
    unsigned char *crcptr;
    unsigned char crc_hi,crc_lo,byte_temp;
    //unsigned short crc16Result;
    
    int i;

    crc_hi=0x00;
    crc_lo=0x00;
    crcptr=frame;	    //数据起始地址
    for(i=0; i<len; i++)
    {
        byte_temp=crc_hi ^ *(crcptr+i);
        crc_hi=crc_lo ^ *(CRC16_hi_lut+byte_temp);
        crc_lo=*(CRC16_lo_lut+byte_temp);
    }
    return (crc_lo|crc_hi<<8);
//	frame[len-2]=crc_lo;
//	frame[len-1]=crc_hi;
}

uint16_t CRC16_Get_2(unsigned char *frame, unsigned int len)
{
    unsigned char *crcptr;
    unsigned char crc_hi,crc_lo,byte_temp;
    //unsigned short crc16Result;
    
    int i;

    crc_hi=0x00;
    crc_lo=0x00;
    crcptr=frame;	    //数据起始地址
    for(i=0; i<len-2; i++)
    {
        byte_temp=crc_hi ^ *(crcptr+i);
        crc_hi=crc_lo ^ *(CRC16_hi_lut+byte_temp);
        crc_lo=*(CRC16_lo_lut+byte_temp);
    }
    return (crc_lo|crc_hi<<8);
//	frame[len-2]=crc_lo;
//	frame[len-1]=crc_hi;
}

//               功能：帧CRC-16的校验 (高低字节分别查表法)                            //
// 参数：数据帧                                                                       ...
// 返回值：0-CRC校验正确，1-CRC校验错误                                                      ...

unsigned int CRC16_check(unsigned char *frame, unsigned int len)
{
    unsigned char *crcptr;
    unsigned char crc_hi,crc_lo,byte_temp;
    
    int i;

    crc_hi=0x00;
    crc_lo=0x00;
    crcptr=frame;	//数据起始地址
    for(i=0; i<(len-2); i++)
    {
        byte_temp=crc_hi ^ *(crcptr+i);
        crc_hi=crc_lo ^ *(CRC16_hi_lut+byte_temp);
        crc_lo=*(CRC16_lo_lut+byte_temp);
    }

    if(frame[len-2]==crc_hi && frame[len-1]==crc_lo )
        return 0;
    else
        return 1;
}

void crc16Test(void)
{
    
    unsigned char crcdata[12]= {0x15,0x68,0x23,0x19,0x78,0x05,0x69,0x34,0x83,0x00,0x00,0x00};
    
    unsigned int result;
    CRC16_build(crcdata,12);
    result=CRC16_check(crcdata,12);
}

unsigned short getCRC_hand(unsigned char* buf, unsigned int len)
{
    unsigned int i,j;
    unsigned short crc,flag;
    crc=0x0000;
    for(i=0; i<len; i++)
    {
        crc^= (((unsigned short)buf[i])<<8);
        for(j=0; j<8; j++)
        {
            flag=crc&0x8000;
            crc<<=1;
            if(flag)
            {
                crc&= 0xfffe;
                crc ^= 0x8005;
            }
        }
    }
    
    return crc;
}
/*  */

unsigned char cs0[512] =
{
    0x00,0x00,0xc0,0xc1,0xc1,0x81,0x01,0x40,0xc3,0x01,0x03,0xc0,0x02,0x80,0xc2,0x41,
    0xc6,0x01,0x06,0xc0,0x07,0x80,0xc7,0x41,0x05,0x00,0xc5,0xc1,0xc4,0x81,0x04,0x40,
    0xcc,0x01,0x0c,0xc0,0x0d,0x80,0xcd,0x41,0x0f,0x00,0xcf,0xc1,0xce,0x81,0x0e,0x40,
    0x0a,0x00,0xca,0xc1,0xcb,0x81,0x0b,0x40,0xc9,0x01,0x09,0xc0,0x08,0x80,0xc8,0x41,
    0xd8,0x01,0x18,0xc0,0x19,0x80,0xd9,0x41,0x1b,0x00,0xdb,0xc1,0xda,0x81,0x1a,0x40,
    0x1e,0x00,0xde,0xc1,0xdf,0x81,0x1f,0x40,0xdd,0x01,0x1d,0xc0,0x1c,0x80,0xdc,0x41,
    0x14,0x00,0xd4,0xc1,0xd5,0x81,0x15,0x40,0xd7,0x01,0x17,0xc0,0x16,0x80,0xd6,0x41,
    0xd2,0x01,0x12,0xc0,0x13,0x80,0xd3,0x41,0x11,0x00,0xd1,0xc1,0xd0,0x81,0x10,0x40,
    0xf0,0x01,0x30,0xc0,0x31,0x80,0xf1,0x41,0x33,0x00,0xf3,0xc1,0xf2,0x81,0x32,0x40,
    0x36,0x00,0xf6,0xc1,0xf7,0x81,0x37,0x40,0xf5,0x01,0x35,0xc0,0x34,0x80,0xf4,0x41,
    0x3c,0x00,0xfc,0xc1,0xfd,0x81,0x3d,0x40,0xff,0x01,0x3f,0xc0,0x3e,0x80,0xfe,0x41,
    0xfa,0x01,0x3a,0xc0,0x3b,0x80,0xfb,0x41,0x39,0x00,0xf9,0xc1,0xf8,0x81,0x38,0x40,
    0x28,0x00,0xe8,0xc1,0xe9,0x81,0x29,0x40,0xeb,0x01,0x2b,0xc0,0x2a,0x80,0xea,0x41,
    0xee,0x01,0x2e,0xc0,0x2f,0x80,0xef,0x41,0x2d,0x00,0xed,0xc1,0xec,0x81,0x2c,0x40,
    0xe4,0x01,0x24,0xc0,0x25,0x80,0xe5,0x41,0x27,0x00,0xe7,0xc1,0xe6,0x81,0x26,0x40,
    0x22,0x00,0xe2,0xc1,0xe3,0x81,0x23,0x40,0xe1,0x01,0x21,0xc0,0x20,0x80,0xe0,0x41,
    0xa0,0x01,0x60,0xc0,0x61,0x80,0xa1,0x41,0x63,0x00,0xa3,0xc1,0xa2,0x81,0x62,0x40,
    0x66,0x00,0xa6,0xc1,0xa7,0x81,0x67,0x40,0xa5,0x01,0x65,0xc0,0x64,0x80,0xa4,0x41,
    0x6c,0x00,0xac,0xc1,0xad,0x81,0x6d,0x40,0xaf,0x01,0x6f,0xc0,0x6e,0x80,0xae,0x41,
    0xaa,0x01,0x6a,0xc0,0x6b,0x80,0xab,0x41,0x69,0x00,0xa9,0xc1,0xa8,0x81,0x68,0x40,
    0x78,0x00,0xb8,0xc1,0xb9,0x81,0x79,0x40,0xbb,0x01,0x7b,0xc0,0x7a,0x80,0xba,0x41,
    0xbe,0x01,0x7e,0xc0,0x7f,0x80,0xbf,0x41,0x7d,0x00,0xbd,0xc1,0xbc,0x81,0x7c,0x40,
    0xb4,0x01,0x74,0xc0,0x75,0x80,0xb5,0x41,0x77,0x00,0xb7,0xc1,0xb6,0x81,0x76,0x40,
    0x72,0x00,0xb2,0xc1,0xb3,0x81,0x73,0x40,0xb1,0x01,0x71,0xc0,0x70,0x80,0xb0,0x41,
    0x50,0x00,0x90,0xc1,0x91,0x81,0x51,0x40,0x93,0x01,0x53,0xc0,0x52,0x80,0x92,0x41,
    0x96,0x01,0x56,0xc0,0x57,0x80,0x97,0x41,0x55,0x00,0x95,0xc1,0x94,0x81,0x54,0x40,
    0x9c,0x01,0x5c,0xc0,0x5d,0x80,0x9d,0x41,0x5f,0x00,0x9f,0xc1,0x9e,0x81,0x5e,0x40,
    0x5a,0x00,0x9a,0xc1,0x9b,0x81,0x5b,0x40,0x99,0x01,0x59,0xc0,0x58,0x80,0x98,0x41,
    0x88,0x01,0x48,0xc0,0x49,0x80,0x89,0x41,0x4b,0x00,0x8b,0xc1,0x8a,0x81,0x4a,0x40,
    0x4e,0x00,0x8e,0xc1,0x8f,0x81,0x4f,0x40,0x8d,0x01,0x4d,0xc0,0x4c,0x80,0x8c,0x41,
    0x44,0x00,0x84,0xc1,0x85,0x81,0x45,0x40,0x87,0x01,0x47,0xc0,0x46,0x80,0x86,0x41,
    0x82,0x01,0x42,0xc0,0x43,0x80,0x83,0x41,0x41,0x00,0x81,0xc1,0x80,0x81,0x40,0x40
};

unsigned int crc_check1(unsigned int nd,unsigned int vd[15])
{
    
    int i;
    
    unsigned int s;

    s=0x1f;//'0;
    for (i=0; i<=nd; i++)
    {
        s^=vd[i];
    }
    if(s==0)
        vd[nd]=0;//=s;
    else
        vd[nd]=1;
    
    return s;
}

void crc_produce1(unsigned int nd,unsigned int vd[15])
{
    
    int i;

    vd[nd]=0x1f;//'0;
    for (i=0; i<nd; i++)
    {
        vd[nd]^=vd[i];
    }
}

unsigned short CRC16_8005(unsigned char *data,unsigned int offset,unsigned int len)
{
    
    unsigned int i = 0;
    unsigned char J,G1,GO;
    
    unsigned short crc = 0;

    J = data[offset++];
    G1 = data[offset++];
    GO = data[offset++];

    for(i = 0; i < len; i++)
    {
        GO = (unsigned char)(GO ^ cs0[(J & 0xff) * 2]);
        J = (unsigned char)(G1 ^ cs0[(J & 0xff) * 2 + 1]);
        G1 = GO;
        GO = (i < len -3) ? data[offset++] : 0;
    }
    crc = (unsigned short)((G1 & 0xff) * 256 + (J & 0xff));
    
    return crc;
}

unsigned int Add_SLIP(unsigned int *data,unsigned int datalen)
{
    
    unsigned char ntemp[200];
    
    unsigned int i = 0;
    
    unsigned int k = 0;
    for(i = 0; i < datalen; i++)
    {
        ntemp[i] = data[i];
    }
    data[k] = 0xc0;
    k++;
    for(i = 0; i < datalen; i++)
    {
        if(ntemp[i] == 0xc0)
        {
            data[k] = 0xdb;
            k++;
            data[k] = 0xdc;
            k++;
        }
        else if(ntemp[i] == 0xdb)
        {
            data[k] = 0xdb;
            k++;
            data[k] = 0xdd;
            k++;
        }
        else
        {
            data[k] = ntemp[i];
            k++;
        }
    }
    data[k] = 0xc0;
    k++;
    
    return k;//加上SLIP之后的数据长度
}

unsigned int Remove_SLIP(unsigned int *data)
{
    
    unsigned char ntemp[400];
    
    unsigned int i = 0;
    
    unsigned int k = 0;
    for(i = 0; i < 400; i++)
    {
        ntemp[i] = data[i];
    }
    if(ntemp[0] != 0xc0)
    {

        return 0;
    }
    i = 1;
    while((ntemp[i] != 0xc0) && (i < 398))
    {
        if((ntemp[i] == 0xdb) && (ntemp[i+1] == 0xdc))
        {
            data[k] = 0xc0;
            k++;
            i+=2;
        }
        else if((ntemp[i] == 0xdb) && (ntemp[i+1] == 0xdd))
        {
            data[k] = 0xdb;
            k++;
            i+=2;
        }
        else
        {
            data[k] = ntemp[i];
            k++;
            i++;
        }
    }
    if(i >= 398)
    {

        return 0;
    }
    
    return k;//去除SLIP之后的数据长度
}
