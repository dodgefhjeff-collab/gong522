# Keil uVision project LN-ZK580D300T28DNJG-host.uvprojx, settings and files
target LN-ZK580D300T28DNJG-host (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LN-ZK580D300T28DNJG-host +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,GD32C103V_EVAL
  c include: ..\CMSIS\GD\GD32C10x\Include;..\HARDWARE;..\STM32F10x_FWLib\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\eeprom;..\USER;..\CMSIS;..\IAP;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
    ../CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group USER
    ./: gd32c10x_it.c main.c systick.c power.c power_eeprom.c
  group FWLIB
    ../STM32F10x_FWLib/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_ctc.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/eeprom/: iic.c 24cxx.c
  group HARDWARE
    ../HARDWARE/: GPIO.c timer.c DMA.c NVIC.c adc.c my_printf.c
  group IAP
    ../IAP/: iap_APP.c iap_crc.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS_MemMang
    ../FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.1.2
